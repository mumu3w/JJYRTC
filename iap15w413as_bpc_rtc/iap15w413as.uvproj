# Keil uVision project iap15w413as.uvproj, settings and files
target iap15w413as (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: iap15w413as +hex
  c flags: Optimize=7 SizeSpeed=1
  group src
    ./: iap15w413as.h iap15w413as_config.c main.c timer.c uart.c led.c bpc.c time.c ds3231.c
