# Keil uVision project iap15w4k58s4.uvproj, settings and files
target iap15w4k58s4 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: iap15w4k58s4 +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: iap15w4k58s4.h main.c iap15w4k58s4_config.c uart.c timer.c update_time.c ds1302.c lcd1602.c
